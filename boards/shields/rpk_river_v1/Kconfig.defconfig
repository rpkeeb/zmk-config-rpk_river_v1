## boards/shields/rpk_river_v1/Kconfig.defconfig
```kconfig
if SHIELD_RPK_RIVER_V1

config ZMK_KEYBOARD_NAME
    default "rpk_river_v1"

endif # SHIELD_RPK_RIVER_V1
```
